# Keil uVision project stm32f405.uvprojx, settings and files
target stm32f405 (6210000::V6.21::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: stm32f405 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F405xx
  c include: ../Core/Inc;../RT-Thread;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/RealThread_RTOS/include/;../Middlewares/Third_Party/RealThread_RTOS/bsp/_template/cubemx_config;../Middlewares/Third_Party/RealThread_RTOS/finsh/;../Middlewares/Third_Party/RealThread_RTOS/components/finsh;..\SEGGER_RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/RT-Thread/RTOS/kernel
    ../Middlewares/Third_Party/RealThread_RTOS/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
    ../Middlewares/Third_Party/RealThread_RTOS/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../Middlewares/Third_Party/RealThread_RTOS/bsp/_template/cubemx_config/: board.c
  group Middlewares/RT-Thread/RTOS/shell
    ../Middlewares/Third_Party/RealThread_RTOS/components/finsh/: cmd.c finsh_port.c msh.c shell.c
  group SEGGER/RTT
    ../SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
software components: CMSIS:CORE 5.6.0

# Keil uVision project stm32f405rgt.uvprojx, settings and files
target stm32f405rgt (6210000::V6.21::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: stm32f405rgt +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F405xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../SEGGER_RTT;../simplefoc/common;../simplefoc/common/base_classes;../components/DWT;../components/bsp_pwm;../user;../simplefoc/sensors;../simplefoc/drivers;../simplefoc;../simplefoc/current_sense;..\components\bsp_adc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group simplefoc/common
    ../simplefoc/common/: defaults.h foc_utils.cpp lowpass_filter.cpp pid.cpp time_utils.cpp
  group simplefoc/basic_class
    ../simplefoc/common/base_classes/: BLDCDriver.h CurrentSense.cpp FOCMotor.cpp Sensor.cpp
  group simplefoc/sensors
    ../simplefoc/sensors/: HallSensor.cpp
  group simplefoc/drivers
    ../simplefoc/drivers/: BLDCDriver6PWM.cpp
  group simplefoc/current_sense
    ../simplefoc/current_sense/: LowsideCurrentSense.cpp InlineCurrentSense.cpp
  group simplefoc
    ../simplefoc/: BLDCMotor.cpp
  group SEGGER/RTT
    ../SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group components
    ../components/DWT/: dwt_timer.c
    ../components/bsp_pwm/: bsp_pwm.c
    ../components/bsp_adc/: bsp_adc.c
  group user
    ../user/: user_main.cpp
software components: CMSIS:CORE 5.6.0
